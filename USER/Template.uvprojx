# Keil uVision project Template.uvprojx, settings and files
target 111 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWOR\LED;..\HARDWOR\RTC;..\HARDWOR\LCD;..\HARDWOR\RTC;..\HARDWOR\KEY;..\HARDWOR\BEEP;..\HARDWOR\EXTI;..\HARDWOR\WDG;..\USMART;..\HARDWOR\OLED
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: stm32f10x_it.c system_stm32f10x.c main.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_bkp.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_rtc.c stm32f10x_tim.c
  group HARDWOR
    ../HARDWOR/LED/: LED.c
    ../HARDWOR/KEY/: KEY.c
    ../HARDWOR/RTC/: rtc.c
    ../HARDWOR/BEEP/: BEEP.c
    ../HARDWOR/OLED/: oled.c
  group USMART
    ../USMART/: usmart.c usmart_config.c usmart_str.c
